# Keil uVision project Freertos的嵌入式智能天气时钟.uvprojx, settings and files
target Freertos的嵌入式智能天气时钟 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Freertos的嵌入式智能天气时钟 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\Core\Inc;..\Drivers\STM32F1xx_HAL_Driver\Inc;..\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy;..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\Drivers\CMSIS\Include;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;.\app;.\app\icon;.\driver;.\driver\st7735;.\driver\esp-at;.\driver\mpu6050;.\user
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/User
    ./app/: boot_splash.c weather.c font_temper_32.c font_time_48.c delay.c
    ./app/icon/: icon_weather_duoyun.c icon_weather_feng.c icon_weather_qing.c icon_weather_xue.c icon_weather_yin.c icon_weather_yu.c
    ./user/: freertos_demo.c
  group Drivers/BSP
    ./driver/: led.c rtc.c
    ./driver/st7735/: st7735.c lcd_spi.c stfonts.c
    ./driver/esp-at/: esp_at.c esp_usart.c
    ./driver/mpu6050/: mpu6050.c swi2c.c
  group Drivers/HAL
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group Core
    ../Core/Src/: main.c gpio.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c system_stm32f1xx.c
  group FreeRTOS
    ../FreeRTOS/source/: tasks.c queue.c list.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group Startup
    ./: startup_stm32f103xb.s
